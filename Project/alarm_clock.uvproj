# Keil uVision project alarm_clock.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: alarm_clock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\main
  group Source Group 1
    ./: STARTUP.A51
    ../main/: main.c i2c.c ds18b20.c display.c button.c
    ../: readme.txt
